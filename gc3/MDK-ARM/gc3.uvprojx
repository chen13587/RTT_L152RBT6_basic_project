# Keil uVision project gc3.uvprojx, settings and files
target gc3 (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gc3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L152xB, USE_HAL_DRIVER,LOG_USE_SPI_FLASH,STM32_BOOT
  c include: ..\..\gc3;..\applications;..\drivers;..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\Libraries\STM32L1xx_HAL_Driver\Inc;..\Libraries\CMSIS\Include;..\rt_thread\include;..\rt_thread\libcpu\arm\cortex-m3;..\rt_thread\libcpu\arm\common;..\rt_thread\components\drivers\include;..\rt_thread\components\finsh;..\rt_thread\components\libc\compilers\armlibc;..\..\gc3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Application
    ../applications/: main.c
  group Drivers
    ../drivers/: board.c drv_usart.c stm32l1xx_it.c
  group STM32_HAL
    ../Libraries/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l152xb.s
  group Kernel
    ../: rtconfig.h
    ../rt_thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CORTEX-M3
    ../rt_thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../rt_thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../rt_thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../rt_thread/components/drivers/serial/: serial.c
  group finsh
    ../rt_thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group libc
    ../rt_thread/components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
software components: CMSIS:CORE 4.3.0
